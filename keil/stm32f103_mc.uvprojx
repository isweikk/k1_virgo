# Keil uVision project stm32f103_mc.uvprojx, settings and files
target motion_control (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pico_stm32f103_mc +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\platform\CMSIS;..\platform\FWlib\inc;..\src\bsp;..\src\common;..\src\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../src/app/: main.c data_scope_service.c event_manager.c lcd_img.c motion_control.c general_api.c
    ../src/app/mpu6050/: mpu_iic.c mpu6050.c
    ../src/app/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group bsp
    ../src/bsp/: adc.c console.c encoder.c exti.c misc_dev.c motor.c oled.c soft_iic.c sys.c timers.c ultrasonic_wave.c usart2.c usart3.c stm32f10x_it.c
  group device
    ../platform/CMSIS/: core_cm3.c system_stm32f10x.c
    ../platform/startup/: startup_stm32f10x_md.s
  group FWlib
    ../platform/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.0.1
